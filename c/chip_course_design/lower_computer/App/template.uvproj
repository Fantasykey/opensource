# Keil uVision project template.uvproj, settings and files
target Template (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Inc;..\App;..\Src
  group Inc
    ../Inc/: type.h config.h led.h key.h beep.h color.h motor.h nixie_tube.h uart.h timer0.h analyse.h task.h
  group Src
    ../Src/: led.c key.c beep.c color.c analyse.c motor.c nixie_tube.c uart.c timer0.c
  group App
    ../App/: main.c user_init.h
